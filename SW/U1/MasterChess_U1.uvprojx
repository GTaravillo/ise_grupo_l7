# Keil uVision project MasterChess_U1.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MasterChess_U1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group config
    ./src/config/: NetConfig.h Paths.h
  group common
    ./src/common/: CommonDefines.h CommonDefines.c
  group main
    ./src/: main.c
  group Server
    ./src/servidor/: server.c server.h server_CGI.c server_CGI.h
    src/web/: Web.c
  group Web files
    ./src/web/: historico.cgi index.htm leaderboard.cgi nuevaPartida.cgi retomarPartida.cgi xml_http.js currentDate.cgx currentTime.cgx favicon.ico currentConsumo.cgx
  group adc
    ./src/adc/: adc.c adc.h
  group buttons
    ./src/buttons/: buttons.c buttons.h
  group lcd
    ./src/lcd/: Arial12x12.h lcd.c lcd.h
  group led
    ./src/led/: led.c led.h LedStripManager.c LedStripManager.h
  group rtc
    ./src/rtc/: rtc.c rtc.h stm32f4xx_hal_msp.c
  group irq
    ./src/irq/: stm32f4xx_it.c stm32f4xx_it.h
  group position
    ./src/posicion/: PositionManager.c PositionManager.h
  group com_placas
    ./src/com_placas/: ComunicacionPlacas.c ComunicacionPlacas.h
  group memoria
    ./src/memoria/: Memoria.c Memoria.h TestMemoria.c TestMemoria.h
  group juego
    ./src/juego/: juego.c juego.h movimiento.c movimiento.h prediction.c prediction.h principal.c principal.h tablero.h
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:SNTP Client 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, CMSIS Driver:USART 2.13, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:SRAM 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
